# Keil uVision project Project_1_20202.uvproj, settings and files
target 8051 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project_1_20212 +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: main.c port.h
  group lib
    ./: LCD1602.c LCD1602.h delay.c delay.h ADC0804.c ADC0804.h HS1101.c HS1101.h
